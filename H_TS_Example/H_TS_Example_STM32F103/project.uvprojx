# Keil uVision project project.uvprojx, settings and files
target Default (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no-multibyte-chars
  c include: .\Code\APP;.\Code\Package;.\Code\STM32;.\Code\STM32\CMSIS;.\Code\STM32\STM32F1xx;.\Code\STM32\STM32F1xx_HAL_Driver\Inc;.\Code\STM32\USB\Core;.\Code\STM32\USB;.\Code\BSP;.\Code\BSP\Instance;.\Code\BSP\InternalPeripherals\HAL;.\Code\BSP\InternalPeripherals\IP;.\Code\BSP\MemoryMalloc;.\Code\BSP\Peripherals;.\Code\H_Lib;.\Code\H_ThreadScheduler
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./Code/APP/: app_main.c
  group Package\H_FIFO_Builder
    ./Code/Package/H_FIFO_Builder/: H_FIFO_Builder.c
  group Package\H_Stream
    ./Code/Package/H_Stream/: H_Reader.c H_Reader_Ext.c H_Stream.c H_Stream_Ext.c H_Writer.c H_Writer_Ext.c
  group Package\NET_Interface
    ./Code/Package/NET_Interface/: NET_Interface.c NET_Interface_Ext.c
  group STM32
    ./Code/STM32/: Entry.c H_Printf.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c stm32f1xx_it_ASM.s stm32xxx_it.c stm32xxx_Time.c system_stm32f1xx.c
  group STM32\STM32F1xx
    ./Code/STM32/STM32F1xx/arm/: startup_stm32f103xb.s
  group STM32\STM32F1xx_HAL_Driver
    ./Code/STM32/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group BSP
    ./Code/BSP/: Bootloader.c Peripheral.c
  group BSP\Instance
    ./Code/BSP/Instance/: I_Button.c I_DebugPort.c Peripherals_Instence.c
  group BSP\InternalPeripherals\HAL
    ./Code/BSP/InternalPeripherals/HAL/: dma.c gpio.c tim.c usart.c
  group BSP\InternalPeripherals\IP
    ./Code/BSP/InternalPeripherals/IP/: IP_DMA.c IP_DMA_Ext.c IP_PLL.c IP_SPI.c IP_SPI_Ext.c IP_USART.c IP_USART_Ext.c
  group BSP\MemoryMalloc
    ./Code/BSP/MemoryMalloc/: MemoryMalloc.c MemoryMalloc_SRAM.c
  group BSP\Peripherals
    ./Code/BSP/Peripherals/: H_Key.c OLED.c OLED_Ext.c
  group H_Lib
    ./Code/H_Lib/: H_FIFO.c H_FIFO_byte.c H_FIFO_uint16.c H_FIFO_uint32.c H_FIFO_uint64.c H_Malloc.c H_Memory.c H_MemoryMalloc.c H_String.c
  group H_ThreadScheduler\API
    ./Code/H_ThreadScheduler/API/: H_ThreadScheduler.c H_ThreadScheduler_BinarySemaphore.c H_ThreadScheduler_Core.c H_ThreadScheduler_Core_Ext.c H_ThreadScheduler_Ext.c H_ThreadScheduler_Lock.c H_ThreadScheduler_Mailbox.c H_ThreadScheduler_MessageQueue.c H_ThreadScheduler_Semaphore.c H_ThreadScheduler_Thread.c H_ThreadScheduler_Thread_Ext.c
  group H_ThreadScheduler\LL
    ./Code/H_ThreadScheduler/LL/: H_ThreadScheduler_LL.c H_ThreadScheduler_LL_ASM.s H_ThreadScheduler_LL_Ext.c H_ThreadScheduler_Memory.c
  group retarget
    ./: retarget.c
target AC6 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: project
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
