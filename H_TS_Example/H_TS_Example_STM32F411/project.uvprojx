# Keil uVision project project.uvprojx, settings and files
target Default (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,__TARGET_FPU_VFP,__FPU_PRESENT,ARM_MATH_CM4
  c misc: --no-multibyte-chars
  c include: .\Code\APP;.\Code\Package;.\Code\STM32;.\Code\STM32\CMSIS;.\Code\STM32\STM32F4xx;.\Code\STM32\STM32F4xx_HAL_Driver\Inc;.\Code\STM32\USB\Core;.\Code\STM32\USB;.\Code\BSP;.\Code\BSP\Instance;.\Code\BSP\InternalPeripherals\HAL;.\Code\BSP\InternalPeripherals\IP;.\Code\BSP\MemoryMalloc;.\Code\BSP\Peripherals;.\Code\H_Lib;.\Code\H_ThreadScheduler
  memory RVCT3: ROM 0x8004000 size 0x8000
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ./Code/APP/: app_main.c
  group Package\H_FIFO_Builder
    ./Code/Package/H_FIFO_Builder/: H_FIFO_Builder.c
  group Package\H_Stream
    ./Code/Package/H_Stream/: H_Reader.c H_Reader_Ext.c H_Stream.c H_Stream_Ext.c H_Writer.c H_Writer_Ext.c
  group Package\NET_Interface
    ./Code/Package/NET_Interface/: NET_Interface.c NET_Interface_Ext.c
  group STM32
    ./Code/STM32/: Entry.c H_Printf.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c stm32xxx_Time.c stm32xxx_it.c system_stm32f4xx.c stm32f4xx_it.s
  group STM32\STM32F4xx
    ./Code/STM32/STM32F4xx/arm/: startup_stm32f411xe.s
  group STM32\STM32F4xx_HAL_Driver
    ./Code/STM32/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group STM32\STM32F4xx_HAL_Driver_Ext
    ./Code/STM32/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_uart.c
  group BSP
    ./Code/BSP/: Bootloader.c Peripheral.c
  group BSP\Instance
    ./Code/BSP/Instance/: I_Button.c I_DebugPort.c Peripherals_Instence.c
  group BSP\InternalPeripherals\HAL
    ./Code/BSP/InternalPeripherals/HAL/: dma.c gpio.c tim.c usart.c
  group BSP\InternalPeripherals\IP
    ./Code/BSP/InternalPeripherals/IP/: IP_DMA.c IP_DMA_Ext.c IP_GPIO_Ext.c IP_I2S.c IP_I2S_Ext.c IP_PLL.c IP_SPI.c IP_SPI_Ext.c IP_USART.c IP_USART_Ext.c
  group BSP\MemoryMalloc
    ./Code/BSP/MemoryMalloc/: MemoryMalloc.c MemoryMalloc_SRAM.c
  group BSP\Peripherals
    ./Code/BSP/Peripherals/: H_Key.c OLED.c OLED_Ext.c
  group H_Lib
    ./Code/H_Lib/: H_FIFO.c H_FIFO_byte.c H_FIFO_uint16.c H_FIFO_uint32.c H_FIFO_uint64.c H_Malloc.c H_Memory.c H_MemoryMalloc.c H_String.c
  group H_ThreadScheduler\API
    ./Code/H_ThreadScheduler/API/: H_ThreadScheduler.c H_ThreadScheduler_Core.c H_ThreadScheduler_Lock.c H_ThreadScheduler_BinarySemaphore.c H_ThreadScheduler_Semaphore.c H_ThreadScheduler_MessageQueue.c H_ThreadScheduler_Thread.c H_ThreadScheduler_Ext.c H_ThreadScheduler_Core_Ext.c H_ThreadScheduler_Thread_Ext.c H_ThreadScheduler_Mailbox.c
  group H_ThreadScheduler\LL
    ./Code/H_ThreadScheduler/LL/: H_ThreadScheduler_LL.c H_ThreadScheduler_LL_Ext.c H_ThreadScheduler_Memory.c H_ThreadScheduler_LL_ASM.s
