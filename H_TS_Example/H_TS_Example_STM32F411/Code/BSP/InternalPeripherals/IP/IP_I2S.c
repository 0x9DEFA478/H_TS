/*
 * @Author: 0x9DEFA478
 * @Date: 2021-08-23 22:30:02
 * @LastEditTime: 2021-08-24 16:04:27
 * @LastEditors: 0x9DEFA478
 * @Description: 
 * QQ:2652450237
 * ============================================================================================================================================
 * 
 * 
 * 
 *                                                                                               ************      ****************************
 *                                                                                             ************      ****************************  
 *                                                                                           ************      ****************************    
 *                                                                                         ************      ****************************      
 *                                                                                       ************      ************                        
 *                                                                                     ************      ************                          
 *                                                                                   ************      ************                            
 *                                                                                 ************      ************                              
 *                                                                               ************      ************                                
 *                                                                             ************      ************                                  
 *                                                                           ************      ************                                    
 *                                                                         ************      ************                                      
 *                                                                       ************      ************                                        
 *                                                                     ************      ************                                          
 *                                                                   ************      ************                                            
 *                                                                 ************      ************                                              
 *                                                               ************      ************                                                
 *                                                             ************      ************                                                  
 *                                                           ************      ************                                                    
 *                                                         ************      ************                                                      
 *                                                       ************      ************                                                        
 *                                                     ************      ************                                                          
 *                                                   ************      ************                                                            
 *                                                 ************      ************                                                              
 *                                               ************      ************                                                                
 *                                             ************      ************                                                                  
 *                                           ************      ************                                                                    
 *                                         ************      ************                                                                      
 *                                       ************      ************                                                                        
 *                                     ************      ************                                                                          
 *                                   ************      ************                                                                            
 *                                 ************      ************                                                                              
 *                               ************      ************                                                                                
 *                             ************      ************                                                                                  
 *                           ************      ************                                                                                    
 *                         ************      ************                                                                                      
 *       ****************************      ************                                                                                        
 *     ****************************      ************                                                                                          
 *   ****************************      ************                                                                                            
 * ****************************      ************                                                                                              
 * 
 * 
 * 
 * ============================================================================================================================================
 * 
 */
#include "IP_I2S.h"




void IP_I2S_DMA_IRQ_tx_m(IP_I2S* ip_i2s){
  void* Data;

  if((cIP_I2S_txDMA(ip_i2s)->CR&DMA_SxCR_EN)==0U){

    oIP_DMA_ClearAllBit_IFCR(ip_i2s->Instance.DMA_Tx);
    //dma未使能 返回
    return;
  }

  if(oIP_DMA_GetTC_ISR(ip_i2s->Instance.DMA_Tx)!=0U){//完成中断
    oIP_DMA_ClearTC_IFCR(ip_i2s->Instance.DMA_Tx);//清除标志位

    Data=ip_i2s->GetData_Callback(ip_i2s->Callback_v);
    if(Data==((void*)0)){
      for(;;){
        //空指针异常
      }
    }
    else{
      if((cIP_I2S_txDMA(ip_i2s)->CR&DMA_SxCR_CT)!=0U){//正在使用缓存1

        cIP_I2S_txDMA(ip_i2s)->M0AR=(unsigned int)Data;
      }
      else{//正在使用缓存0

        cIP_I2S_txDMA(ip_i2s)->M1AR=(unsigned int)Data;
      }
    }
  }else{
    for(;;){
      //未实现对应的中断处理
    }
  }



}











