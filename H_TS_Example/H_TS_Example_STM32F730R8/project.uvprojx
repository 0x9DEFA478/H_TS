# Keil uVision project project.uvprojx, settings and files
target Default (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F730R8Tx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20010000,0x30000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x10000) IROM2(0x00200000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F730xx,__TARGET_FPU_VFP,__FPU_PRESENT,ARM_MATH_CM7
  c include: .\Code\STM32;.\Code\STM32\CMSIS;.\Code\STM32\STM32F7xx;.\Code\STM32\STM32F7xx_HAL_Driver\Inc;.\Code\BSP;.\Code\BSP\Instence;.\Code\BSP\InternalPeripherals;.\Code\BSP\Peripherals;.\Code\H_Lib;.\Code\H_ThreadScheduler
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group STM32
    ./Code/STM32/: Entry.c main.c stm32f7xx_hal_msp.c stm32f7xx_it.c stm32xxx_Time.c system_stm32f7xx.c
  group STM32\STM32F7xx
    ./Code/STM32/STM32F7xx/arm/: startup_stm32f730xx.s
  group STM32\STM32F7xx_HAL_Driver_Ext
    ./Code/STM32/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c
  group BSP
    ./Code/BSP/: JumpBoot.c Peripheral.c
  group BSP\InternalPeripherals
    ./Code/BSP/InternalPeripherals/: IP_PLL.c IP_GPIO_Ext.c
  group H_Lib
    ./Code/H_Lib/: H_Malloc.c
  group H_ThreadScheduler\API
    ./Code/H_ThreadScheduler/API/: H_ThreadScheduler.c H_ThreadScheduler_Core.c H_ThreadScheduler_Lock.c H_ThreadScheduler_MessageQueue.c H_ThreadScheduler_Semaphore.c H_ThreadScheduler_Core_Ext.c H_ThreadScheduler_Ext.c H_ThreadScheduler_Lock_Ext.c H_ThreadScheduler_MessageQueue_Ext.c H_ThreadScheduler_MultipleQueue.c H_ThreadScheduler_MultipleQueue_Ext.c H_ThreadScheduler_Semaphore_Ext.c H_ThreadScheduler_Thread.c H_ThreadScheduler_Thread_Ext.c
  group H_ThreadScheduler\LL
    ./Code/H_ThreadScheduler/LL/: H_ThreadScheduler_LL.c H_ThreadScheduler_LL_Ext.c H_ThreadScheduler_LL_ASM.s H_ThreadScheduler_Memory.c
